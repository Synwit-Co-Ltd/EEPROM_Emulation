# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_Lib\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;..\SWM320;..\..\EEPROM_Emulation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_gpio.c SWM320_timr.c SWM320_uart.c SWM320_flash.c SWM320_port.c
  group CSL\CMSIS
    ../../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_Lib/SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
