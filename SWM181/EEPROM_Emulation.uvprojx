# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM181 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM181_Lib\SWM181_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM181_Lib\SWM181_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM181_Lib\SWM181_StdPeriph_Driver\CSL\SWM181_StdPeriph_Driver;..\SWM181;..\..\EEPROM_Emulation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM181_Lib/SWM181_StdPeriph_Driver/CSL/SWM181_StdPeriph_Driver/: SWM181_gpio.c SWM181_timr.c SWM181_uart.c SWM181_flash.c SWM181_port.c SWM181_cache.c SWM181_irqmux.c
  group CSL\CMSIS
    ../../SWM181_Lib/SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ../../SWM181_Lib/SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
