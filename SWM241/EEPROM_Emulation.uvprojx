# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM241 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM241xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM241_Lib\SWM241_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM241_Lib\SWM241_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM241_Lib\SWM241_StdPeriph_Driver\CSL\SWM241_StdPeriph_Driver;..\SWM241;..\..\EEPROM_Emulation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM241_Lib/SWM241_StdPeriph_Driver/CSL/SWM241_StdPeriph_Driver/: SWM241_gpio.c SWM241_timr.c SWM241_uart.c SWM241_flash.c SWM241_port.c
  group CSL\CMSIS
    ../../SWM241_Lib/SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM241.c
    ../../SWM241_Lib/SWM241_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM241.s
