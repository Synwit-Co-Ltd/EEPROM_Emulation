# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM190 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM190xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM190_Lib\SWM190_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM190_Lib\SWM190_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM190_Lib\SWM190_StdPeriph_Driver\CSL\SWM190_StdPeriph_Driver;..\SWM190;..\..\EEPROM_Emulation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM190_Lib/SWM190_StdPeriph_Driver/CSL/SWM190_StdPeriph_Driver/: SWM190_gpio.c SWM190_timr.c SWM190_uart.c SWM190_flash.c SWM190_port.c
  group CSL\CMSIS
    ../../SWM190_Lib/SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../../SWM190_Lib/SWM190_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
