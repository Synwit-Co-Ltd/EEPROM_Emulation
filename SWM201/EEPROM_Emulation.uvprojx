# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM201 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM201x6 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: CHIP_SWM201 SW_LOG_LEVEL = 3
  c include: ..\..\SWM2X1_Lib\SWM2X1_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM2X1_Lib\SWM2X1_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM2X1_Lib\SWM2X1_StdPeriph_Driver\CSL\SWM2X1_StdPeriph_Driver;..\SWM201;..\..\EEPROM_Emulation
  asm define: CHIP_SWM201
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM2X1_Lib/SWM2X1_StdPeriph_Driver/CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_gpio.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_port.c SWM201_flash.c
  group CSL\CMSIS
    ../../SWM2X1_Lib/SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM201.c
    ../../SWM2X1_Lib/SWM2X1_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s
