# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;..\;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_flash.c SWM341_gpio.c SWM341_port.c SWM341_timr.c SWM341_uart.c
  group CSL\CMSIS
    ../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
