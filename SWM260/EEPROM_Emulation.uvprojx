# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM260 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM260xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\SWM260_Lib\SWM260_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM260_Lib\SWM260_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM260_Lib\SWM260_StdPeriph_Driver\CSL\SWM260_StdPeriph_Driver;..\SWM260;..\..\EEPROM_Emulation
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM260_Lib/SWM260_StdPeriph_Driver/CSL/SWM260_StdPeriph_Driver/: SWM260_gpio.c SWM260_timr.c SWM260_uart.c SWM260_flash.c SWM260_port.c
  group CSL\CMSIS
    ../../SWM260_Lib/SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ../../SWM260_Lib/SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM260.s
