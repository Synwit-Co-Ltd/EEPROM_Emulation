# Keil uVision project EEPROM_Emulation.uvprojx, settings and files
target SWM221 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM221xB Synwit
  pack: Synwit.SWM32_DFP.2.1.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EEPROM_Emulation
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=1
  c define: CHIP_SWM221
  c include: ..\..\SWM221_Lib\SWM221_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM221_Lib\SWM221_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM221_Lib\SWM221_StdPeriph_Driver\CSL\SWM221_StdPeriph_Driver;..\..\EEPROM_Emu;..\SWM221
  asm define: CHIP_SWM221
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./: main.c
    ../: eeprom_emulation.c
  group CSL\StdPD
    ../../SWM221_Lib/SWM221_StdPeriph_Driver/CSL/SWM221_StdPeriph_Driver/: SWM221_port.c SWM221_gpio.c SWM221_exti.c SWM221_timr.c SWM221_uart.c SWM221_adc.c SWM221_i2c.c SWM221_pwm.c SWM221_wdt.c SWM221_div.c SWM221_spi.c SWM221_qei.c SWM221_dma.c SWM221_can.c SWM221_flash.c SWM221_iofilt.c SWM221_mpu.c SWM221_qspi.c SWM221_crc.c SWM221_usart.c
  group CSL\CMSIS
    ../../SWM221_Lib/SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM221.c
    ../../SWM221_Lib/SWM221_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM221.s
